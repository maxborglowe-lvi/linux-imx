## lib/lviconfig/Kconfig
```kconfig
config CONFIG_LVICONFIG
    bool "LVI Config Library"
    help
      Generic library for LVI system configuration used across kernel components
```
